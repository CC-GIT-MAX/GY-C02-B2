# IAR project C02_B2.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: YTM32B1MD14 YTM32B1MD14
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: YTM32B1MD1; CPU_YTM32B1MD1
  ICCARM.CCIncludePath2: ../board; ../platform/drivers/src/clock/YTM32B1Mx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/linflexd; ../platform/drivers/src/flexcan; ../platform/drivers/src/i2c; ../platform/drivers/src/lptmr; ../platform/drivers/src/etmr; ../platform/drivers/src/adc; ../platform/drivers/src/power/YTM32B1Mx; ../platform/drivers/src/wdg; ../platform/drivers/src/flash; ../platform/drivers/inc; ../platform/drivers/inc/etmr; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1MD1/include; ../platform/devices/YTM32B1MD1/startup; ../CMSIS/Core/Include; ../rtos/osif; ../middleware/utility_print/printf; ../app; ../app/can; ../app/init; ../app/log; ../app/rti; ../app/scheduler; ../app/signal; ../app/storage; ../app/mod_template
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../board; ../platform/drivers/src/clock/YTM32B1Mx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/linflexd; ../platform/drivers/src/flexcan; ../platform/drivers/src/i2c; ../platform/drivers/src/lptmr; ../platform/drivers/src/etmr; ../platform/drivers/src/adc; ../platform/drivers/src/power/YTM32B1Mx; ../platform/drivers/src/wdg; ../platform/drivers/src/flash; ../platform/drivers/inc; ../platform/drivers/inc/etmr; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1MD1/include; ../platform/devices/YTM32B1MD1/startup; ../CMSIS/Core/Include; ../rtos/osif; ../middleware/utility_print/printf
  OBJCOPY.OOCOutputFile: C02_B2.hex
  ILINK.IlinkOutputFile: C02_B2.out
  ILINK.IlinkIcfFile: ../board/yt_linker.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app
    ../app/: main.c result.h types.h
  group app/can
    ../app/can/: can_db.c can_db.h can_db_codec.c can_db_codec.h can_db_ipk_gen.c can_db_ipk_gen.h can_if.c can_if.h can_rx.c can_rx.h can_tx.c can_tx.h
  group app/init
    ../app/init/: bsp_init.c bsp_init.h drv_init.c drv_init.h
  group app/log
    ../app/log/: log.c log.h
  group app/rti
    ../app/rti/: rti.c rti.h rti_defer.c rti_defer.h
  group app/scheduler
    ../app/scheduler/: scheduler.c scheduler.h
    ../app/rti/: rti_defer.c rti_defer.h
  group app/signal
    ../app/signal/: signal.c signal.h signal_test.c
  group app/storage
    ../app/storage/: kv.c kv.h
  group app/mod_template
    ../app/mod_template/: mod_template.c mod_template.h
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h startup.S vector.S vector_table_copy.c yt_linker.icf RamInit0.S RamInit1.c RamInit2.c interrupt_config.c interrupt_config.h dma_config.c dma_config.h linflexd_uart_config.c linflexd_uart_config.h can_config.c can_config.h i2c_config.c i2c_config.h lptmr_config.c lptmr_config.h etmr_config.c etmr_config.h adc_config.c adc_config.h power_config.c power_config.h wdg_config.c wdg_config.h flash_config.h flash_config.c utility_print_config.h utility_print_config.c sdk_project_config.h
  group CMSIS/Core/Include
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group middleware/utility_print/printf
    ../middleware/utility_print/printf/: printf.c printf.h
  group platform/drivers/src/clock/YTM32B1Mx
    ../platform/drivers/src/clock/YTM32B1Mx/: cfmu_hw_access.h clock_YTM32B1Mx.c clock_YTM32B1Mx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
  group platform/drivers/src/clock/YTM32B1Mx/doxygen
    ../platform/drivers/src/clock/YTM32B1Mx/doxygen/: clock_YTM32B1Mx.dox
  group platform/drivers/src/pins
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group platform/drivers/src/pins/doxygen
    ../platform/drivers/src/pins/doxygen/: pins.dox
  group platform/drivers/src/interrupt
    ../platform/drivers/src/interrupt/: interrupt_manager.c
  group platform/drivers/src/interrupt/doxygen
    ../platform/drivers/src/interrupt/doxygen/: interrupt.dox
  group platform/drivers/src/dma
    ../platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
  group platform/drivers/src/dma/doxygen
    ../platform/drivers/src/dma/doxygen/: dma_driver.dox
  group platform/drivers/src/linflexd
    ../platform/drivers/src/linflexd/: linflexd_uart_driver.c linflexd_uart_irq.c linflexd_uart_irq.h linflexd_hw_access.h
  group platform/drivers/src/flexcan
    ../platform/drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_hw_access.h flexcan_irq.c flexcan_irq.h
  group platform/drivers/src/flexcan/doxygen
    ../platform/drivers/src/flexcan/doxygen/: flexcan_driver.dox
  group platform/drivers/src/i2c
    ../platform/drivers/src/i2c/: i2c_driver.c i2c_hw_access.h i2c_irq.c i2c_irq.h
  group platform/drivers/src/i2c/doxygen
    ../platform/drivers/src/i2c/doxygen/: i2c.dox i2c_driver.dox
  group platform/drivers/src/lptmr
    ../platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c lptmr_hw_access.h
  group platform/drivers/src/lptmr/doxygen
    ../platform/drivers/src/lptmr/doxygen/: lptmr.dox lptmr_driver.dox
  group platform/drivers/src/etmr
    ../platform/drivers/src/etmr/: etmr_common.c etmr_hw_access.c etmr_hw_access.h etmr_pwm_driver.c
  group platform/drivers/src/adc
    ../platform/drivers/src/adc/: adc_driver.c adc_hw_access.h
  group platform/drivers/src/adc/doxygen
    ../platform/drivers/src/adc/doxygen/: adc_driver.dox
  group platform/drivers/src/power
    ../platform/drivers/src/power/: power_manager.c
  group platform/drivers/src/power/YTM32B1Mx
    ../platform/drivers/src/power/YTM32B1Mx/: power_manager_YTM32B1Mx.c power_manager_YTM32B1Mx.h
  group platform/drivers/src/wdg
    ../platform/drivers/src/wdg/: wdg_driver.c wdg_hw_access.c wdg_hw_access.h
  group platform/drivers/src/wdg/doxygen
    ../platform/drivers/src/wdg/doxygen/: wdg.dox
  group platform/drivers/src/flash
    ../platform/drivers/src/flash/: flash_driver.c flash_hw_access.h
  group platform/drivers/src/flash/doxygen
    ../platform/drivers/src/flash/doxygen/: flash_driver.dox
  group platform/drivers/inc
    ../platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h linflexd_uart_driver.h linflexd_lin_driver.h flexcan_driver.h i2c_driver.h lptmr_driver.h adc_driver.h power_manager.h wdg_driver.h flash_driver.h
  group platform/drivers/inc/etmr
    ../platform/drivers/inc/etmr/: etmr_common.h etmr_pwm_driver.h
  group platform/devices
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
  group platform/devices/common
    ../platform/devices/common/: core_common.h
  group platform/devices/YTM32B1MD1/include
    ../platform/devices/YTM32B1MD1/include/: YTM32B1MD1.h YTM32B1MD1_features.h
  group platform/devices/YTM32B1MD1/startup
    ../platform/devices/YTM32B1MD1/startup/: system_YTM32B1MD1.c system_YTM32B1MD1.h
  group rtos/osif
    ../rtos/osif/: osif.h osif_baremetal.c
